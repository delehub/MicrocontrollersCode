# Keil uVision project Demo.uvproj, settings and files
target Demo (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Demo
    ./: main.c
